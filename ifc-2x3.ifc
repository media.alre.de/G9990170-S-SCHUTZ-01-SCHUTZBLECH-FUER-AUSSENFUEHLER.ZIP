Properties of the parts of a building model (IFC2X3)

# File
Description: Ball-, Sonnen- und Regenschutz, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990170, Ball-, Sonnen- und Regenschutz
In: Raum
Description: Ball-, Sonnen- und Regenschutz, 150 x 90x47 mm, Edelstahl V4A 1.4571; Classification: EC011349 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990170; ModelLabel: S-Schutz 01; GlobalTradeItemNumber: 4050528044105; ProductURL: https://alre.de/produkt_G9990170
Pset_Specification - NominalLength: 0.15 m; NominalWidth: 0.135 m; NominalDepth: 0.047 m; NetWeight: 0.288
Pset_ALRE_ETIM_Properties - ETIM-Klasse: EC011349; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990170.pdf
